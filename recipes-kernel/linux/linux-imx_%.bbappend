FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
  
SRC_URI += "file://0001-linux-imx-framos.patch"
